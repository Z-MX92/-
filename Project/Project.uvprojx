# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\Lib;..\User;..\User\Hardware;..\Project;..\Start;..\User\Hardware\OLED;..\User\Hardware\LED;..\User\Hardware\KEY;..\User\Hardware\BUZZER;..\User\Hardware\MLX90614;..\System\delay;..\System\sys;..\System\timer;..\System\usart;..\User\Hardware;..\User\Hardware\MAX30102;..\User\Hardware\MPU6050;..\User\Hardware\MPU6050\DMP;..\User\Hardware\MPU6050\IIC;..\Net;..\Net\esp8266;..\User\Hardware\HX710;..\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Lib
    ../Lib/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ../System/delay/: delay.c delay.h
    ../System/sys/: sys.c sys.h
    ../System/usart/: usart.c usart.h
    ../System/: MyRTC.c MyRTC.h
  group User
    ../User/: main.c main.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ../User/Hardware/LED/: LED.c LED.h
    ../User/Hardware/KEY/: KEY.c KEY.h
    ../User/Hardware/BUZZER/: Buzzer.c Buzzer.h
    ../User/Hardware/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h My_OLED.c My_OLED.h
    ../User/Hardware/MLX90614/: mlx90614.c mlx90614.h
    ../User/Hardware/MAX30102/: algorithm.c algorithm.h max30102.c max30102.h maxiic.c maxiic.h
    ../User/Hardware/: Menu.c Menu.h
    ../User/Hardware/HX710/: xgz6847a.c xgz6847a.h xgz6847a_bp.c xgz6847a_bp.h
  group MPU6050
    ../User/Hardware/MPU6050/: MPU_IIC.c MPU_IIC.h MPU6050.c MPU6050.h
  group Net
    ../Net/esp8266/: esp8266.c esp8266.h
